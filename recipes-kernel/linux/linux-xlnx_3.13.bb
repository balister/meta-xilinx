# See include file for common information
include linux-xlnx.inc

# Track linux-xlnx until 3.14 merged in
LINUX_VERSION = "3.13"
KBRANCH = "master-next"
SRCREV = "4052625ea34d274559343b9e1b367d6229a92e0d"

