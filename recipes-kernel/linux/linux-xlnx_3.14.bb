# See include file for common information
include linux-xlnx.inc

# Track linux-xlnx until 3.15 merged in
LINUX_VERSION = "3.14"
KBRANCH = "master-next"
SRCREV = "59a0da8b5a471d7f4addd610760a13dd521e686e"

